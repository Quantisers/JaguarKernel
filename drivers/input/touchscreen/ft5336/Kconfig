## drivers/input/touchscreen/ft5336/Kconfig
```kconfig
config TOUCHSCREEN_FT5336
	boolean "FOCALTECH FT5336 touchpanel driver"
	depends on CONFIG_INPUT_TOUCHSCREEN
	default n
```
